<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>datvexpress_tonegen</value></param>
<param><key>title</key><value>Simple tone generator</value></param>
<param><key>description</key><value>Generates a single sine wave</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>datvexpress_sink_c</key>
<param><key>id</key><value>datvexpress_sink_c_0</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>freq</key><value>frequency</value></param>
<param><key>level</key><value>gain</value></param>
<param><key>ical</key><value>ical</value></param>
<param><key>qcal</key><value>qcal</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>cwoffs</value></param>
<param><key>amp</key><value>tone_ampl</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate [Hz]</value></param>
<param><key>value</key><value>2048000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tone_ampl</value></param>
<param><key>label</key><value>Tone ampl</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1.0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>cwoffs</value></param>
<param><key>label</key><value>Tone offset [Hz]</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF level</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>46</value></param>
<param><key>num_steps</key><value>47</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>RF freq [Hz]</value></param>
<param><key>value</key><value>434100000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ical</value></param>
<param><key>label</key><value>I cal</value></param>
<param><key>value</key><value>0</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>qcal</value></param>
<param><key>label</key><value>Q cal</value></param>
<param><key>value</key><value>0</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6,0,1,1</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>datvexpress_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
